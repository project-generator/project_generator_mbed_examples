# IAR project template.ewp, settings and files
configuration  (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AExtraOptionsV2: 0
  OBJCOPY.OOCOutputFile: lpc1768_blinky.bin
  ILINK.IlinkProgramEntryLabel: __iar_program_start
